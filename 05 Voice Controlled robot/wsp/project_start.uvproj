# Keil uVision project project_start.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: at89s52_hex +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\drv\offchip_drivers\include;..\drv\onchip_drivers\include;..\app\include;..\drv
  group Source Group 1
    ./: STARTUP.A51
    ../app/: main.c
    ../drv/offchip_drivers/src/: lcd4bit.c
    ../drv/onchip_drivers/src/: delay.c
    ../drv/: motor_control.c uart.c bluetooth.c
